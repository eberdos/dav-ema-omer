Commit message: Comparison plot RMSE vs CoM average velocity

File: urdf/ground.urdf (robot description, URDF)
Before this commit: robot ground_skeleton, 2 links, 1 joints
Links:
- link ground_link: geometry collision box size=15 15 1; visual box size=15 15 1
